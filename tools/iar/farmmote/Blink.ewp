# IAR project Blink.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2252 MSP430F2252
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CPU_MHZ=4; PLATFORM_FARMMOTE=1; MCU_MSP430=1; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_SERIAL; USE_SPI; USE_CRC; USE_LEDS; USE_ALARMS; USE_ASSERT; USE_RADIO; USE_PRINT
  ICC430.newCCIncludePaths: ..\..\..\mos; ..\..\..\mos\kernel; ..\..\..\mos\platforms\farmmote; ..\..\..\mos\arch\msp430; ..\..\..\mos\chips
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2252.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../mos/kernel/: alarms.c alarms_system.h defines.h defines_iar.h kernelmain.c sleep.c
    ../../../mos/hil/: alarms.h gpio.h leds.c leds.h spi.c spi.h usart.c usart.h
    ../../../mos/lib/: assert.c assert.h dprint.c dprint.h
    ../../../mos/chips/cc1101/: cc1101.c cc1101.h
    ../../../mos/platforms/farmmote/: cc1101_pins.h flash.h ledslist.h platform.c platform.h platform_radio.h sht_pins.h
    ../../../mos/chips/ds18b20/: ds18b20.c ds18b20.h
    ../../../mos/platforms/telosb/: flash.h ledslist.h
    ../../../mos/arch/msp430/: gpio_hal.h udelay_hal.h
    ../../../apps/demo/Blink/: main.c
    ../../../mos/chips/msp430/: msp430_adc.h msp430_adc10.h msp430_clock.h msp430_int.h msp430_timers.c msp430_timers.h msp430_usci.h msp430_usci_spi.c msp430_usci_uart.c msp430x1xx_clock.c
    ../../../mos/kernel/nothreads/: timing.c
