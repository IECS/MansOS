# IAR project mansos.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2252 MSP430F2252
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_ADC; USE_SERIAL; USE_SPI; USE_LEDS; USE_ALARMS; USE_SERIAL_NUMBER; USE_CRC; USE_ASSERT; USE_RADIO; USE_PRINT; CPU_MHZ=1; PLATFORM_FARMMOTE; ACLK_SPEED=32768; MCU_MSP430
  ICC430.newCCIncludePaths: ..\..\..\mos\fs\sdcard; ..\..\..\mos; ..\..\..\mos\kernel; ..\..\..\mos\lib; ..\..\..\mos\net; ..\..\..\mos\hil; ..\..\..\mos\arch\msp430; ..\..\..\mos\platforms\farmmote; ..\..\..\mos\chips
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2252.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../../../mos/hil/: adc.c errors.c leds.c mem.c spi.c usart.c
    ../../../mos/kernel/: alarms.c kernelmain.c sleep.c
    ../../../mos/lib/: assert.c dprint.c usart_packet.c
    ../../../mos/chips/cc1101/: cc1101.c
    ../../../mos/lib/codec/: crc.c
    ../../../mos/chips/ds18b20/: ds18b20.c
    ../../../mos/chips/ds2411/: ds2411.c
    ../../../apps/demo/Blink/: main.c
    ../../../mos/chips/msp430/: msp430_timers.c msp430_usci_spi.c msp430_usci_uart.c msp430x1xx_clock.c
    ../../../mos/PLATFORMS/farmmote/: platform.c
    ../../../mos/kernel/nothreads/: timing.c
