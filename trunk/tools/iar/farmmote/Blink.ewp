# IAR project Blink.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2252 MSP430F2252
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: USE_ROLE_BASE_STATION; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_ADC; USE_SERIAL; USE_RANDOM; USE_HUMIDITY; USE_SPI; USE_SERIAL_NUMBER; USE_LEDS; USE_SIMPLE_MHOP; USE_ALARMS; USE_CRC; USE_ASSERT; USE_RADIO; USE_ROLE_BASE_STATION; USE_PRINT; CPU_MHZ=1; PLATFORM_FARMMOTE=1; ACLK_SPEED=32768; MCU_MSP430=1
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..\..\..\mos\include; ..\..\..\mos; ..\..\..\mos\kernel; ..\..\..\mos\lib; ..\..\..\mos\lib\processing; ..\..\..\mos\net; ..\..\..\mos\hil; ..\..\..\mos\arch\msp430; ..\..\..\mos\platforms\farmmote; ..\..\..\mos\chips
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2252.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  ICC430.CCDefines: CPU_MHZ=4; PLATFORM_FARMMOTE=1; MCU_MSP430=1; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_SERIAL; USE_SPI; USE_CRC; USE_LEDS; USE_ALARMS; USE_ASSERT; USE_RADIO; USE_PRINT
  ICC430.newCCIncludePaths: ..\..\..\mos; ..\..\..\mos\kernel; ..\..\..\mos\platforms\farmmote; ..\..\..\mos\arch\msp430; ..\..\..\mos\chips
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../mos/hil/: adc.c errors.c leds.c mem.c random.c serial.c spi.c
    ../../../mos/kernel/: alarms.c kernelmain.c sleep.c
    ../../../mos/lib/: assert.c dprint-radio.c dprint-serial.c dprint.c usart_packet.c
    ../../../mos/chips/cc1101/: cc1101.c
    ../../../mos/lib/codec/: crc.c
    ../../../mos/chips/ds18b20/: ds18b20.c
    ../../../mos/chips/ds2411/: ds2411.c
    ../../../apps/demo/Blink/: main.c
    ../../../mos/chips/msp430/: msp430_usci_spi.c msp430_usci_uart.c msp430x1xx_clock.c
    ../../../mos/platforms/farmmote/: platform.c
    ../../../mos/fatfs/: posix-stdio.c
    ../../../mos/chips/sht11/: sht11.c sht11_conv.c
    ../../../mos/net/: simple_mhop.c
    ../../../mos/kernel/nothreads/: timing.c
