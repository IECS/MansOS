# IAR project Blink.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CPU_MHZ=1; PLATFORM_FR=1; MCU_MSP430=1; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_SERIAL; USE_SPI; USE_CRC; USE_LEDS; USE_ALARMS; USE_ASSERT; USE_PRINT
  ICC430.newCCIncludePaths: ..\..\..\mos; ..\..\..\mos\kernel; ..\..\..\mos\platforms\fr; ..\..\..\mos\arch\msp430; ..\..\..\mos\chips
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../mos/kernel/: alarms.c alarms_system.h defines.h defines_iar.h kernelmain.c sleep.c
    ../../../mos/hil/: alarms.h errors.c errors.h gpio.h leds.c leds.h spi.c spi.h usart.c usart.h
    ../../../mos/lib/: assert.c assert.h dprint.c dprint.h
    ../../../mos/platforms/fr/: flash.h ledslist.h platform.c platform.h
    ../../../mos/arch/msp430/: gpio_hal.h udelay_hal.h
    ../../../mos/platforms/telosb/: ledslist.h
    ../../../apps/demo/Blink/: main.c
    ../../../mos/chips/msp430/: msp430_adc10.h msp430_clock.h msp430_int.h msp430_timers.c msp430_timers.h msp430fr57xx_clock.c msp430fr57xx_usci.h msp430fr57xx_usci_i2c.c msp430fr57xx_usci_spi.c msp430fr57xx_usci_uart.c
    ../../../mos/kernel/nothreads/: timing.c
